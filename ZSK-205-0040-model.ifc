Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:47+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-205-0040
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-205-0040 Тематический игровой комплекс «Ноев Ковчег»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс «Ноев Ковчег»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-205-0040; ModelReference: Тематический игровой комплекс «Ноев Ковчег»; ProductionYear: 2026; ArticleNumber: ZSK-205-0040
ORION_Изделие - Артикул: ZSK-205-0040; Артикул прежний: SD-205-0040; Наименование: Тематический игровой комплекс «Ноев Ковчег»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 4.9 x 4.6 м; Зона безопасности: 7.9 x 7.6 м; Высота свободного падения: 0.9 м; Возраст: для детей от 2 до 5 лет; Цена: 5 921 360 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/themed/3002; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс «Ноев Ковчег»; ADSK_Марка: ZSK-205-0040; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/themed/3002
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 5 лет; ZSK_Зона_безопасности: 7.9 x 7.6 м; ZSK_Высота_свободного_падения: 0.9 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-205-0040
Qto_ORION - Длина: 4900 mm; Ширина: 4600 mm; Высота: 0 mm
